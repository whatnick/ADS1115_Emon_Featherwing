# Repository whatnick/ADS1115_Emon_Featherwing

## EAGLE design ADS1115_Featherwing.brd

Parts:
0X4A, 0X4B, 0X48, 0X49: SJ
B1: MB8S; SOIC-4
C1: 10uF; 153CLV-0405
C2: 100uF 50V; 153CLV-0810
C3, C4: 1µF; 0603
C5, C6, C7, C8: 33nF; 0603
D1: 20V-1A; SOD-123
FB1, FB2: MMZ2012Y152B; 0603
J1: CON_DC_M-DC_SMD; DC_BARREL_JACK_SMD_2MM
J2: ST-PJ-312; AUDIO6P-SMD-3.5-14.0X6.4X5.0MM
J3: 4P-SMD-2.0-90D; HW4-SMD-2.0-90D
MS1: FEATHERWING
PWR: GREEN; LED-0603
R1: 120K; R0603
R2: 10K; R0603
R3, R4, R5, R11: 10K; 0603
R6: 100R; 0603
R7, R9, R10, R13: 1K; 0603
R8, R12: VARISTORCN0603; CT/CN0603
R14: 1k; R0603
U1: SR05
U2: ADS1115IDGST; MSOP10

Connections:
3V: C4.1, FB1.1, J3.3, MS1.2 (3V)
ADDR: 0X4A.1, 0X4B.1, 0X48.1, 0X49.1, R11.1, U2.1 (ADDR)
AGND: B1.-, C1.-, C2.-, C4.2, FB2.1, J3.4, J3.SS1, J3.SS2, MS1.4 (GND), PWR.-, U1.P$2 (GND)
ALERT: R5.2, U2.2 (ALERT)
GND: 0X48.2, C3.1, C5.2, C6.1, C7.2, C8.1, FB2.2, R11.2, U2.3 (GND)
I_AC+: J2.COM1, R6.1, R10.1
I_AC-: J2.L, R6.2, R13.1
unnamed: C6.2, R8.2, R9.2, U2.5 (AIN1)
unnamed: C1.+, D1.+, U1.P$3 (OUT)
unnamed: B1.~1 (AC1), J1.P2, R1.1
unnamed: B1.+, C2.+, U1.P$1 (IN)
unnamed: C5.1, R7.2, R8.1, U2.4 (AIN0)
unnamed: C7.1, R10.2, R12.1, U2.6 (AIN2)
unnamed: C8.2, R12.2, R13.2, U2.7 (AIN3)
unnamed: PWR.+, R14.2
SCL: 0X4B.2, J3.1, MS1.18 (GPIOSCL), R3.2, U2.10 (SCL)
SDA: 0X4A.2, J3.2, MS1.17 (GPIOSDA), R4.2, U2.9 (SDA)
USB: D1.-, MS1.26 (USB), R14.1
VDD: 0X49.2, C3.2, FB1.2, R3.1, R4.1, R5.1, U2.8 (VDD)
V_AC+: B1.~2 (AC2), J1.P1@2 (P1), R2.2, R7.1
V_AC-: R1.2, R2.1, R9.1

Notes on the sheet:
Default I²C Address = 1001000 (0x48)

Board: 2 copper layers, 53.9 x 22.7 mm, 37 parts (24 on the bottom side), 21 nets.

## Commit log

2015-12-26 Initial import
2015-12-26 Added labels
2016-01-18 Rewired fixed board
2016-01-20 Added grove connector
2016-01-22 Switched to 50V electrolytic
2016-01-22 Added protection resistor
2016-02-18 Switched to XP Power Vreg
2016-02-18 Renumber parts/reversion
2016-02-18 Wire thickness fix
2016-02-18 Rewired with better net names
2016-02-21 Added clamper and power LED
2016-02-21 Reposition parts
2016-03-07 Flipped V_AC pins
